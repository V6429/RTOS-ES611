# Keil uVision project exp3.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2148 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: exp3 +hex
  AfterMake: fromelf --bin exp3.axf -o out.bin
  c flags: Optim=1
  memory RVCT4: ROM 0x2000 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: Startup.s main.c
    ./includes/: gpio.c send_sensordata.c spi0.c uart.c utils.c timer1.c
